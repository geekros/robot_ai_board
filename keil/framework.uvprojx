# Keil uVision project framework.uvprojx, settings and files
target framework (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: framework +hex
  AfterMake: fromelf.exe --bin --output "#L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_STM3210E_EVAL
  c include: ..\hardware\main\inc;..\hardware\mcu\driver\inc;..\hardware\mcu\core\inc;..\hardware\utils\inc;..\hardware\system\include;..\hardware\system\portable\RVDS\ARM_CM3;..\hardware\app\inc;..\hardware\mcu\usb\inc;..\hardware\module\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group app
    ../hardware/app/src/: app.c
  group main
    ../hardware/main/src/: main.c module.c utils.c
  group module
    ../hardware/module/src/: adc.c key.c usb.c led.c pwm.c motor.c
  group mcu
    ../hardware/mcu/core/src/: stm32f10x_it.c system_stm32f10x.c
    ../hardware/mcu/: keil_startup.s
  group mcu_driver
    ../hardware/mcu/driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm3210e_eval.c
  group mcu_core
    ../hardware/mcu/core/src/: core_cm3.c
  group mcu_usb
    ../hardware/mcu/usb/src/: hw_config.c usb_core.c usb_desc.c usb_endp.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c usb_sil.c
  group system
    ../hardware/system/: list.c queue.c tasks.c timers.c croutine.c event_groups.c
    ../hardware/system/portable/RVDS/ARM_CM3/: port.c
    ../hardware/system/portable/MemMang/: heap_4.c
  group utils
    ../hardware/utils/src/: cjson.c delay.c
